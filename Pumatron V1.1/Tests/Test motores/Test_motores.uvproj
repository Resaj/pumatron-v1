# Keil uVision project Test_motores.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Test_motores +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s Test_motores.c mando.h s1d15g00.h font.h s1d15g00.c
